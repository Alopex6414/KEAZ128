# Keil uVision project My_KEA_Project.uvprojx, settings and files
target My_KEA (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: SKEAZ128xxx4 Freescale
  pack: Keil.Kinetis_KEAxx_DFP.1.2.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: My_KEA_Project
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\App;..\Board;..\Chip;..\LIB;..\Start
  asm include: ..\Start
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x1ffff000 size 0x4000
  group App
    ../App/: main.c Init.c ISR.c Conf.c
  group Chip
    ../Chip/: ACMP.c ADC.c CAN.c Delay.c FTM.c GPIO.c I2C.c ICS.c IRQ.c PIT.c PWT.c SPI.c UART.c WDOG.c Include.h Common.h PORT_MUX.h
  group Start
    ../Start/: Vector.c System.c StartUp.s
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
